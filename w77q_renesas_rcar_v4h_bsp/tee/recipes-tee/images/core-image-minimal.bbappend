IMAGE_INSTALL:append:sparrow-hawk = " \
    optee-client \
    optee-client-dev \
"
