COMPATIBLE_MACHINE = "sparrow-hawk"
